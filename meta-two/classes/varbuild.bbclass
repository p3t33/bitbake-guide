varbuild_do_build () {
  echo "build with args: ${BUILDARGS}"
}


EXPORT_FUNCTIONS do_build
